File: booster.kicad_sch (KiCad schematic)
At the start: 9 parts, among them U3 MT3608

Commit message: partial wiring and monitor draft
Connections:
- net GND renamed VGND
- net V_OUT renamed V_BSTD
